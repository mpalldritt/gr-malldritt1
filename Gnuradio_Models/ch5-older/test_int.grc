options:
  parameters:
    author: parallels
    generate_options: qt_gui
    id: test_int
    output_language: python
    title: Test integrator
  states: {}

blocks:
- name: block_size
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: press_for_errors
  id: variable_qtgui_push_button
  parameters:
    label: press_for_errors
    pressed: '1'
    released: '0'
    type: real
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: block_size
    repeat: 'True'
    type: byte
  states: {}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    max: '1'
    min: '0'
    num_samps: '1000'
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/parallels/Documents/GRC/FE_SDR/fesdr-examples-vol3/ch5/BER-test-data.dat
    type: byte
  states: {state: disabled}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: '1000'
    type: int
  states: {state: disabled}
- name: blocks_integrate_xx_1
  id: blocks_integrate_xx
  parameters:
    decim: '10'
    type: float
  states: {state: disabled}
- name: blocks_integrate_xx_2
  id: blocks_integrate_xx
  parameters:
    decim: block_size
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: disabled}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0,0,0,0,0)
  states: {}
- name: blocks_xor_xx_0
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: blocks_xor_xx_0_0
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Integral"'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '10'
    name: '"Output from Integrator"'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    name: '"Sum of errors"'
    type: float
    update_time: 10/samp_rate
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"Input Vectors"'
    nconnections: '2'
    size: '20'
    srate: samp_rate
    type: msg_float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Integrator output"'
    size: '20'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Output from the Xor gate"'
    size: 2*block_size
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_xor_xx_0, '0']
- [analog_random_source_x_0, '0', blocks_xor_xx_0_0, '0']
- [analog_random_source_x_0_0, '0', blocks_file_sink_0, '0']
- [blocks_int_to_float_0, '0', qtgui_number_sink_0, '0']
- [blocks_integrate_xx_0, '0', blocks_int_to_float_0, '0']
- [blocks_integrate_xx_1, '0', qtgui_number_sink_1, '0']
- [blocks_integrate_xx_1, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_integrate_xx_2, '0', qtgui_number_sink_2, '0']
- [blocks_throttle_0, '0', blocks_integrate_xx_1, '0']
- [blocks_uchar_to_float_0, '0', blocks_integrate_xx_2, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_vector_source_x_0_0, '0', blocks_xor_xx_0_0, '1']
- [blocks_xor_xx_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_xor_xx_0_0, '0', blocks_xor_xx_0, '1']

metadata:
  file_format: 1
