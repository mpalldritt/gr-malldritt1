options:
  parameters:
    author: MA & RB
    description: Complex channel for Simulator
    generate_options: hb
    id: mp_channel_complex
    output_language: python
    title: '"MP Channel hier block"'
  states: {}

blocks:
- name: air_gain
  id: parameter
  parameters:
    label: Air Gain
    value: '0'
  states: {}
- name: air_velocity
  id: parameter
  parameters:
    label: Air velocity
    value: '340'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(path_length/air_velocity*samp_rate)
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: int(path_length/wood_velocity*samp_rate)
    type: complex
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: int(path_length/steel_velocity*samp_rate)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: air_gain
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: wood_gain
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: steel_gain
    type: complex
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: path_length
  id: parameter
  parameters:
    label: Pth Length
    value: '1'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    value: '0'
  states: {}
- name: steel_gain
  id: parameter
  parameters:
    label: Steel Gain
    value: '0'
  states: {}
- name: steel_velocity
  id: parameter
  parameters:
    label: Steel velocity
    value: '5000'
  states: {}
- name: wood_gain
  id: parameter
  parameters:
    label: Wood Gain
    value: '0'
  states: {}
- name: wood_velocity
  id: parameter
  parameters:
    label: Wood velocity
    value: '3000'
  states: {}

connections:
- [blocks_add_xx_0, '0', pad_sink_0, '0']
- [blocks_delay_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_delay_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_delay_0_1, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_add_xx_0, '2']
- [pad_source_0, '0', blocks_delay_0, '0']
- [pad_source_0, '0', blocks_delay_0_0, '0']
- [pad_source_0, '0', blocks_delay_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
