options:
  parameters:
    generate_options: hb
    id: mpchannel
    output_language: python
    title: Multipath Channel for Steel Wood Air
  states: {}

blocks:
- name: air
  id: parameter
  parameters:
    label: Air
    type: eng_float
    value: '0'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: air
    type: byte
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: wood
    type: byte
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: steel
    type: byte
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0_1
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.333'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.333'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.333'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: sig_out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: sig_in
    type: float
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Samp_rate
    type: eng_float
    value: '0'
  states: {}
- name: steel
  id: parameter
  parameters:
    label: Steel
    type: eng_float
    value: '0'
  states: {}
- name: wood
  id: parameter
  parameters:
    label: Wood
    type: eng_float
    value: '0'
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_char_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_char_to_float_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_char_to_float_0_1, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_delay_0, '0', blocks_char_to_float_0, '0']
- [blocks_delay_0_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_delay_0_1, '0', blocks_char_to_float_0_1, '0']
- [blocks_float_to_uchar_0, '0', blocks_delay_0, '0']
- [blocks_float_to_uchar_0_0, '0', blocks_delay_0_0, '0']
- [blocks_float_to_uchar_0_1, '0', blocks_delay_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_add_xx_0, '2']
- [blocks_throttle_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_float_to_uchar_0, '0']
- [pad_source_0, '0', blocks_float_to_uchar_0_0, '0']
- [pad_source_0, '0', blocks_float_to_uchar_0_1, '0']

metadata:
  file_format: 1
