options:
  parameters:
    author: MA & RB
    description: Simulator for testing multipath
    generate_options: qt_gui
    id: ook_tx_rx_40KHz_10sps
    max_nouts: '1000'
    output_language: python
    title: ook_tx_rx_40KHz_10sps
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 40e3
  states: {}
- name: delay
  id: variable
  parameters:
    comment: |-
      For Symbol_rate = 1, use 42650 steel
      For Symbol_rate = 1, use 42650 wood
      For Symbol_rate = 1, use 42650 air
      For Symbol_rate = 10, use 2200 steel 0r 2900 SA(0.2)
      For Symbol_rate = 10, use 2400 wood
      For Symbol_rate = 100, use 2780 air
      For Symbol_rate = 100, use 262 steel or 282 SA(0.2)
      For Symbol_rate = 100, use 282 wood
      For Symbol_rate = 100, use 530 air
      For Symbol_rate = 1000, use 48 steel or SA/SW
      For Symbol_rate = 1000, use 58 wood
      For Symbol_rate = 1000, use 318 air
    value: '2900'
  states: {}
- name: noise_level
  id: variable
  parameters:
    value: '20'
  states: {}
- name: num_syms
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '10'
  states: {}
- name: analog_const_source_x_1_0_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: analog_const_source_x_1_1
  id: analog_const_source_x
  parameters:
    const: noise_level
    type: float
  states: {}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: noise_level
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: num_syms
    repeat: 'False'
    type: int
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: center_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    comment: |-
      RB>
      All bandwidths etc
      scaled using symbol_rate
    decim: '1'
    gain: '2'
    high_cutoff_freq: center_freq + 5*symbol_rate
    low_cutoff_freq: center_freq - 5*symbol_rate
    samp_rate: samp_rate
    type: fir_filter_fcc
    width: 10*symbol_rate
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    comment: |-
      RB>
      Adjust the delay by 
      inspecting the streams
    delay: delay
    type: float
  states: {}
- name: blocks_divide_xx_0_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/michael/Desktop/Combined desktop folders MA22082025/Gnuradio_Models/ch5/BER-test-data.dat
    type: float
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    comment: |-
      RB>
      Keep increased for symbol rate
      by sps_scalor
    n: int(samp_rate/symbol_rate)
    type: float
  states: {}
- name: blocks_keep_one_in_n_0_0_0
  id: blocks_keep_one_in_n
  parameters:
    comment: |-
      RB>
      Keep increased for symbol rate
      by sps_scalor
    n: int(samp_rate/symbol_rate)
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    comment: |-
      RB> 
      Divide samp_rate by symbol_rate 
      to get samples/symbol
    interp: int(samp_rate/symbol_rate)
    type: int
  states: {}
- name: blocks_threshold_ff_3
  id: blocks_threshold_ff
  parameters:
    high: '0.8'
    init: '0'
    low: '0.2'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: int
    vector: (0, 1)
  states: {state: disabled}
- name: blocks_xor_xx_0
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    comment: |-
      RB>
      Bandwidth scaled
      by sps_scalor
    cutoff_freq: 4*symbol_rate
    gain: '2'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: 10*symbol_rate
    win: window.WIN_HAMMING
  states: {}
- name: mp_channel_complex_0
  id: mp_channel_complex
  parameters:
    air_gain: '0'
    air_velocity: '340'
    comment: |-
      RB>
      No changes needed for 
      different symbol rate
    path_length: '1'
    samp_rate: samp_rate
    steel_gain: '0.8'
    steel_velocity: '5000'
    wood_gain: '0.2'
    wood_velocity: '3000'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 0,0,1,1
    name: '"SNR in dB"'
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"TX Signal"'
    size: int(samp_rate/symbol_rate)*40
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      RB>
      Number of points increased 
      by sps_scalor
    ctrlpanel: 'True'
    entags: 'False'
    label1: TX Signal
    label2: RX Signal
    name: '"Signals (TX and RX)"'
    nconnections: '2'
    size: int(samp_rate/symbol_rate)*50
    srate: samp_rate
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      RB>
      Sample rate scaled by sps_scalor
    label1: TX Symbol
    label2: RX Symbol
    marker2: '0'
    name: '"Data Streams"'
    nconnections: '2'
    size: '100'
    srate: int(symbol_rate)
    style2: '0'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      RB>
      Sample rate scaled by sps_scalor
    label1: Errors
    marker1: '0'
    name: '"Errors"'
    size: '100'
    srate: int(symbol_rate)
    style1: '0'
    tr_level: '0.5'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: TX stream
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: TX signal
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: MP Signal
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: RX Symbols
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: TX Symbols
  states: {}
- name: virtual_sink_3_0
  id: virtual_sink
  parameters:
    stream_id: TX Signals
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: RX Signals
  states: {}
- name: virtual_sink_5
  id: virtual_sink
  parameters:
    stream_id: TX d-Syms
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: TX d-Syms
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: TX stream
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: MP Signal
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: TX signal
  states: {state: disabled}
- name: virtual_source_2_0_0
  id: virtual_source
  parameters:
    stream_id: TX signal
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: TX Symbols
  states: {state: disabled}
- name: virtual_source_3_0
  id: virtual_source
  parameters:
    stream_id: TX Symbols
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: RX Symbols
  states: {state: disabled}
- name: virtual_source_4_0
  id: virtual_source
  parameters:
    stream_id: RX Symbols
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: TX Signals
  states: {}
- name: virtual_source_6
  id: virtual_source
  parameters:
    stream_id: RX Signals
  states: {}

connections:
- [analog_const_source_x_1_0_0, '0', blocks_divide_xx_0_0, '0']
- [analog_const_source_x_1_1, '0', blocks_divide_xx_0_0, '1']
- [analog_noise_source_x_0_0, '0', blocks_add_xx_0_0, '1']
- [analog_random_source_x_0, '0', blocks_repeat_0, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_1, '1']
- [band_pass_filter_1, '0', virtual_sink_1, '0']
- [blocks_add_xx_0_0, '0', band_pass_filter_1, '0']
- [blocks_complex_to_mag_squared_0, '0', low_pass_filter_1, '0']
- [blocks_delay_0, '0', blocks_keep_one_in_n_0_0, '0']
- [blocks_delay_0, '0', virtual_sink_3_0, '0']
- [blocks_divide_xx_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_xor_xx_0, '0']
- [blocks_float_to_uchar_0_0, '0', blocks_xor_xx_0, '1']
- [blocks_int_to_float_0, '0', blocks_multiply_xx_1, '0']
- [blocks_int_to_float_0, '0', virtual_sink_0, '0']
- [blocks_keep_one_in_n_0_0, '0', virtual_sink_3, '0']
- [blocks_keep_one_in_n_0_0_0, '0', virtual_sink_2, '0']
- [blocks_multiply_xx_1, '0', blocks_add_xx_0_0, '0']
- [blocks_nlog10_ff_0_0, '0', qtgui_number_sink_0, '0']
- [blocks_repeat_0, '0', virtual_sink_5, '0']
- [blocks_threshold_ff_3, '0', blocks_keep_one_in_n_0_0_0, '0']
- [blocks_threshold_ff_3, '0', virtual_sink_4, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_uchar_to_float_0, '0', blocks_file_sink_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_vector_source_x_0, '0', blocks_repeat_0, '0']
- [blocks_xor_xx_0, '0', blocks_uchar_to_float_0, '0']
- [low_pass_filter_1, '0', blocks_threshold_ff_3, '0']
- [mp_channel_complex_0, '0', virtual_sink_1_0, '0']
- [virtual_source_0, '0', blocks_int_to_float_0, '0']
- [virtual_source_1, '0', blocks_delay_0, '0']
- [virtual_source_2, '0', blocks_complex_to_mag_squared_0, '0']
- [virtual_source_2_0, '0', blocks_throttle_0, '0']
- [virtual_source_2_0_0, '0', mp_channel_complex_0, '0']
- [virtual_source_3, '0', qtgui_time_sink_x_1_0_0, '0']
- [virtual_source_3_0, '0', blocks_float_to_uchar_0, '0']
- [virtual_source_4, '0', qtgui_time_sink_x_1_0_0, '1']
- [virtual_source_4_0, '0', blocks_float_to_uchar_0_0, '0']
- [virtual_source_5, '0', qtgui_time_sink_x_1_0, '0']
- [virtual_source_6, '0', qtgui_time_sink_x_1_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
