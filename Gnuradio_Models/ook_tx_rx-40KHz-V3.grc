options:
  parameters:
    author: parallels
    generate_options: qt_gui
    id: ook_tx
    max_nouts: '1000'
    output_language: python
    title: OOK  TX RX
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 40e3
  states: {}
- name: delay
  id: variable
  parameters:
    comment: |-
      For Symbol_rate = 10, use 2200
      For Symbol_rate = 100, use 262
      For Symbol_rate = 1000, use 48
    value: '2200'
  states: {}
- name: noise_level
  id: variable
  parameters:
    value: 1/(10**(snr_db/20))
  states: {}
- name: num_syms
  id: variable
  parameters:
    comment: |-
      The number of symbols set here depends on 
      the error rate you are measuring. Only increase
      this if you are looking for very error rates.

      eg. Use 100 if you are looking for error rates less than 0.1
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: snr_db
  id: variable
  parameters:
    comment: |-
      Enter the SNR in dB here. This then
      calculates the voltage level as follows:
      Vn = 1/(10**(snr_db/20))

      Note: ** == ^ in Python
    value: '-15'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '10'
  states: {}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: noise_level
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: num_syms
    repeat: 'False'
    type: int
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Creates the carrier
    freq: center_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    comment: |-
      RB>
      All bandwidths etc
      scaled using symbol_rate
    decim: '1'
    gain: '2'
    high_cutoff_freq: center_freq + 5*symbol_rate
    low_cutoff_freq: center_freq - 5*symbol_rate
    samp_rate: samp_rate
    type: fir_filter_fcc
    width: 10*symbol_rate
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    comment: |-
      RB>
      Adjust the delay by 
      inspecting the streams
    delay: delay
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /media/psf/Home/Documents/FE_SDR/ch5/BER-test-data.dat
    type: float
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    comment: K = samp_rate/symbol_rate
    n: int(samp_rate/symbol_rate)
    type: float
  states: {}
- name: blocks_keep_one_in_n_0_0_0
  id: blocks_keep_one_in_n
  parameters:
    comment: K = samp_rate/symbol_rate
    n: int(samp_rate/symbol_rate)
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    comment: |-
      Divide samp_rate by symbol_rate 
      to get samples/symbol
    interp: int(samp_rate/symbol_rate)
    type: int
  states: {}
- name: blocks_threshold_ff_3
  id: blocks_threshold_ff
  parameters:
    high: '0.8'
    init: '0'
    low: '0.2'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: |-
      Enable this one when measuring the delay
      for synchronisation.

      Then disable the Random Source
    repeat: 'True'
    type: int
    vector: (0, 1)
  states: {state: disabled}
- name: blocks_xor_xx_0
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    comment: |-
      RB>
      Bandwidth scaled
      by sps_scalor
    cutoff_freq: 4*symbol_rate
    gain: '2'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: 10*symbol_rate
    win: window.WIN_HAMMING
  states: {}
- name: mp_channel_complex_0
  id: mp_channel_complex
  parameters:
    air_gain: '0'
    air_velocity: '340'
    comment: |-
      RB>
      No changes needed for 
      different symbol rate
    path_length: '1'
    samp_rate: samp_rate
    steel_gain: '1'
    steel_velocity: '5000'
    wood_gain: '0'
    wood_velocity: '3000'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"TX Signal"'
    size: int(samp_rate/symbol_rate)*40
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      RB>
      Number of points increased 
      by sps_scalor
    ctrlpanel: 'True'
    entags: 'False'
    label1: TX Signal
    label2: RX Signal
    name: '"Signals (TX and RX)"'
    nconnections: '2'
    size: int(samp_rate/symbol_rate)*50
    srate: samp_rate
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      RB>
      Sample rate scaled by sps_scalor
    label1: TX Symbol
    label2: RX Symbol
    marker2: '0'
    name: '"Data Streams"'
    nconnections: '2'
    size: '100'
    srate: int(symbol_rate)
    style2: '0'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    label1: Errors
    marker1: '0'
    name: '"Errors"'
    size: '100'
    srate: int(symbol_rate)
    style1: '0'
    tr_level: '0.5'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: TX stream
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: TX signal
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: MP Signal
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: RX Symbols
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: TX Symbols
  states: {}
- name: virtual_sink_3_0
  id: virtual_sink
  parameters:
    stream_id: TX Signals
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: RX Signals
  states: {}
- name: virtual_sink_5
  id: virtual_sink
  parameters:
    stream_id: TX d-Syms
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: TX d-Syms
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: TX stream
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: MP Signal
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: TX signal
  states: {state: disabled}
- name: virtual_source_2_0_0
  id: virtual_source
  parameters:
    stream_id: TX signal
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: TX Symbols
  states: {state: disabled}
- name: virtual_source_3_0
  id: virtual_source
  parameters:
    stream_id: TX Symbols
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: RX Symbols
  states: {state: disabled}
- name: virtual_source_4_0
  id: virtual_source
  parameters:
    stream_id: RX Symbols
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: TX Signals
  states: {}
- name: virtual_source_6
  id: virtual_source
  parameters:
    stream_id: RX Signals
  states: {}

connections:
- [analog_noise_source_x_0_0, '0', blocks_add_xx_0_0, '1']
- [analog_random_source_x_0, '0', blocks_repeat_0, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_1, '1']
- [band_pass_filter_1, '0', virtual_sink_1, '0']
- [blocks_add_xx_0_0, '0', band_pass_filter_1, '0']
- [blocks_complex_to_mag_squared_0, '0', low_pass_filter_1, '0']
- [blocks_delay_0, '0', blocks_keep_one_in_n_0_0, '0']
- [blocks_delay_0, '0', virtual_sink_3_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_xor_xx_0, '0']
- [blocks_float_to_uchar_0_0, '0', blocks_xor_xx_0, '1']
- [blocks_int_to_float_0, '0', blocks_multiply_xx_1, '0']
- [blocks_int_to_float_0, '0', virtual_sink_0, '0']
- [blocks_keep_one_in_n_0_0, '0', virtual_sink_3, '0']
- [blocks_keep_one_in_n_0_0_0, '0', virtual_sink_2, '0']
- [blocks_multiply_xx_1, '0', blocks_add_xx_0_0, '0']
- [blocks_repeat_0, '0', virtual_sink_5, '0']
- [blocks_threshold_ff_3, '0', blocks_keep_one_in_n_0_0_0, '0']
- [blocks_threshold_ff_3, '0', virtual_sink_4, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_uchar_to_float_0, '0', blocks_file_sink_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_vector_source_x_0, '0', blocks_repeat_0, '0']
- [blocks_xor_xx_0, '0', blocks_uchar_to_float_0, '0']
- [low_pass_filter_1, '0', blocks_threshold_ff_3, '0']
- [mp_channel_complex_0, '0', virtual_sink_1_0, '0']
- [virtual_source_0, '0', blocks_int_to_float_0, '0']
- [virtual_source_1, '0', blocks_delay_0, '0']
- [virtual_source_2, '0', blocks_complex_to_mag_squared_0, '0']
- [virtual_source_2_0, '0', blocks_throttle_0, '0']
- [virtual_source_2_0_0, '0', mp_channel_complex_0, '0']
- [virtual_source_3, '0', qtgui_time_sink_x_1_0_0, '0']
- [virtual_source_3_0, '0', blocks_float_to_uchar_0, '0']
- [virtual_source_4, '0', qtgui_time_sink_x_1_0_0, '1']
- [virtual_source_4_0, '0', blocks_float_to_uchar_0_0, '0']
- [virtual_source_5, '0', qtgui_time_sink_x_1_0, '0']
- [virtual_source_6, '0', qtgui_time_sink_x_1_0, '1']

metadata:
  file_format: 1
