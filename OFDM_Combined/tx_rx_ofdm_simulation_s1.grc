options:
  parameters:
    author: Expanded from GNU Radio examples
    category: Custom
    description: A simulated OFDM Tx and Rx on the same flowgraph
    generate_options: qt_gui
    id: tx_rx_ofdm_simulation_s1
    output_language: python
    run_options: run
    title: An OFDM System Simulation
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '40000'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    comment: A list of Tx blocks
    gui_hint: 0,1,1,1
    label: Gain
    start: '0.001'
    step: '0.01'
    stop: '1'
    value: '0.01'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    value: digital.header_format_ofdm(occupied_carriers, 1, length_tag_key,)
  states: {}
- name: header_equalizer
  id: variable
  parameters:
    value: digital.ofdm_equalizer_simpledfe(fft_len, header_mod.base(), occupied_carriers, pilot_carriers, pilot_symbols)
  states: {}
- name: header_formatter
  id: variable
  parameters:
    value: digital.packet_header_ofdm(occupied_carriers, n_syms=1, len_tag_key=packet_length_tag_key, frame_len_tag_key=length_tag_key, bits_per_header_sym=header_mod.bits_per_symbol(), bits_per_payload_sym=payload_mod.bits_per_symbol(), scramble_header=False)
  states: {}
- name: header_mod
  id: variable
  parameters:
    value: digital.constellation_bpsk()
  states: {}
- name: length_tag_key
  id: variable
  parameters:
    value: '"frame_len"'
  states: {}
- name: lp_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: samp_rate/2
    gain: '1.0'
    samp_rate: samp_rate*upfactor
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: (list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) + list(range(22, 27)),)
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '512'
  states: {}
- name: packet_length_tag_key
  id: variable
  parameters:
    comment: A list of Rx blocks
    value: '"packet_len"'
  states: {}
- name: payload_equalizer
  id: variable
  parameters:
    value: digital.ofdm_equalizer_simpledfe(fft_len, payload_mod.base(), occupied_carriers, pilot_carriers, pilot_symbols, 1)
  states: {}
- name: payload_mod
  id: variable
  parameters:
    value: digital.constellation_qpsk()
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: ((-21, -7, 7, 21,),)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((1, 1, 1, -1,),)
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4410'
  states: {}
- name: sync_word1
  id: variable
  parameters:
    value: '[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]'
  states: {}
- name: sync_word2
  id: variable
  parameters:
    value: '[0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 0, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 0, 0, 0, 0, 0] '
  states: {}
- name: upfactor
  id: variable
  parameters:
    value: '40'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    comment: CFO generation for de-rotation
    sensitivity: '-2.0/fft_len'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: center_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate*upfactor
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: center_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate*upfactor
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '-1'
    freq: center_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate*upfactor
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '-1'
    freq: center_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate*upfactor
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: '""'
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: '""'
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: <-- Upconversion
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    comment: 80=64+16
    delay: fft_len+fft_len//4
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\Michael Alldritt\Desktop\Wireless Pi Qasim Chaudari OFDM\out.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\Michael Alldritt\Desktop\2023 GRC Project Work Tracked & Updated\Text and target files\Gettysburg Address.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters:
    comment: <-- Downconversion
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Gain
    const: gain
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: CFO correction
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    comment: Combines bits for modulation
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: payload_mod.bits_per_symbol()
    len_tag_key: length_tag_key
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: length_tag_key
  states: {}
- name: blocks_repack_bits_bb_0_1
  id: blocks_repack_bits_bb
  parameters:
    comment: Combines demodulated bits into bytes
    endianness: gr.GR_LSB_FIRST
    k: payload_mod.bits_per_symbol()
    l: '8'
    len_tag_key: packet_length_tag_key
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    comment: Adds length tags at regular intervals
    len_tag_key: length_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_tag_debug_1
  id: blocks_tag_debug
  parameters:
    display: 'False'
    name: Rx Bytes
    type: byte
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_tag_gate_0_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    comment: Combines header and payload symbols
    lengthtagname: length_tag_key
    ninputs: '2'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate*upfactor
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*upfactor
    type: complex
  states: {state: disabled}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: header_mod.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: Bits to complex symbols
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: payload_mod.points()
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: Decodes constillation symbols into bits
    constellation: header_mod.base()
  states: {}
- name: digital_constellation_decoder_cb_1
  id: digital_constellation_decoder_cb
  parameters:
    comment: Decodes constillation symbols into bits
    constellation: payload_mod.base()
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    comment: Generates Cyclic Redundancy Check
    lengthtagname: length_tag_key
    packed: 'True'
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    comment: Verifies Cyclic Redundancy Check
    lengthtagname: packet_length_tag_key
    packed: 'True'
  states: {}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    comment: Demultiplexes header and payload
    guard_interval: fft_len//4
    header_len: '3'
    header_padding: '0'
    items_per_symbol: fft_len
    length_tag_key: length_tag_key
    output_symbols: 'True'
    samp_rate: samp_rate
    special_tags: ()
    timing_tag_key: '"rx_time"'
    type: complex
  states: {}
- name: digital_ofdm_carrier_allocator_cvc_0
  id: digital_ofdm_carrier_allocator_cvc
  parameters:
    comment: |-
      - Allocates positions for data and pilot carrires
      - Assigns pilot symbols
      - Prepends sync words before the frame
    fft_len: fft_len
    len_tag_key: length_tag_key
    occupied_carriers: occupied_carriers
    output_is_shifted: 'True'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    sync_words: (sync_word1, sync_word2)
  states: {}
- name: digital_ofdm_chanest_vcvc_0
  id: digital_ofdm_chanest_vcvc
  parameters:
    comment: Estimates CFO and channel response from preamble
    force_one_symbol: 'False'
    max_carr_offset: '3'
    n_data_symbols: '1'
    sync_symbol1: sync_word1
    sync_symbol2: sync_word2
  states: {}
- name: digital_ofdm_cyclic_prefixer_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    comment: Prepends a Cyclic Prefix (CP) before OFDM symbol
    cp_len: fft_len//4
    input_size: fft_len
    rolloff: rolloff
    tagname: length_tag_key
  states: {}
- name: digital_ofdm_frame_equalizer_vcvc_0
  id: digital_ofdm_frame_equalizer_vcvc
  parameters:
    comment: Compensates for channel response
    cp_len: fft_len//4
    equalizer: header_equalizer.base()
    fft_len: fft_len
    fixed_frame_len: '1'
    len_tag_key: length_tag_key
    propagate_channel_state: 'True'
  states: {}
- name: digital_ofdm_frame_equalizer_vcvc_1
  id: digital_ofdm_frame_equalizer_vcvc
  parameters:
    comment: Compensates for channel response
    cp_len: fft_len//4
    equalizer: payload_equalizer.base()
    fft_len: fft_len
    len_tag_key: length_tag_key
    propagate_channel_state: 'True'
  states: {}
- name: digital_ofdm_serializer_vcc_header
  id: digital_ofdm_serializer_vcc
  parameters:
    carr_offset_key: ''
    comment: Outputs complex data symbols
    fft_len: fft_len
    len_tag_key: length_tag_key
    occupied_carriers: occupied_carriers
    packet_len_tag_key: ''
  states: {}
- name: digital_ofdm_serializer_vcc_payload
  id: digital_ofdm_serializer_vcc
  parameters:
    carr_offset_key: ''
    comment: Outputs complex data symbols
    fft_len: fft_len
    len_tag_key: length_tag_key
    occupied_carriers: occupied_carriers
    packet_len_tag_key: packet_length_tag_key
    symbols_skipped: '1'
  states: {}
- name: digital_ofdm_sync_sc_cfb_0
  id: digital_ofdm_sync_sc_cfb
  parameters:
    comment: Timing/frame synchronization
    cp_len: fft_len//4
    fft_len: fft_len
    threshold: '0.9'
  states: {}
- name: digital_packet_headerparser_b_0
  id: digital_packet_headerparser_b
  parameters:
    comment: Inverse block to header generator
    header_formatter: header_formatter.base()
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    comment: Creates the header from the stream
    format: hdr_format
    len_tag_key: length_tag_key
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    comment: Frequency domain to time domain
    fft_size: fft_len
    forward: 'False'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    comment: Time domain to frequency domain
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    comment: Time domain to frequency domain
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    comment: Downsampling to signal bandwidth
    decim: upfactor
    taps: lp_filter_taps
    type: ccc
  states: {}
- name: header_bits
  id: virtual_sink
  parameters:
    stream_id: Header Bits
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    comment: |-
      Upsampling to create spectrum 
      for passband signal
    interp: upfactor
    taps: lp_filter_taps
    type: ccc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    color1: '"red"'
    grid: 'True'
    gui_hint: 4,0,1,1
    legend: 'False'
    marker1: '1'
    name: Constellation at Rx
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 1,1,1,1
    legend: 'False'
    name: Baseband Spectrum
    showports: 'True'
    type: complex
    ymax: '0'
    ymin: '-100'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*upfactor
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 2,0,1,1
    legend: 'False'
    name: Tx Spectrum
    showports: 'True'
    type: float
    ymax: '0'
    ymin: '-120'
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*upfactor
    color1: '"magenta"'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 2,1,1,1
    legend: 'False'
    name: Rx Spectrum
    showports: 'True'
    type: float
    ymax: '0'
    ymin: '-120'
  states: {}
- name: qtgui_freq_sink_x_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 3,1,1,1
    legend: 'False'
    name: Baseband Spectrum
    showports: 'True'
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,0,1,1
    label1: Scope Plot
    legend: 'False'
    name: Tx Baseband Signal
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 3,0,1,1
    legend: 'False'
    name: Rx Baseband Signal
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    color1: magenta
    grid: 'True'
    gui_hint: 0,0,1,1
    legend: 'False'
    marker1: '0'
    name: Data Out of Tx File
    size: '50'
    srate: samp_rate
    stemplot: 'True'
    type: float
    ymax: '128'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 4,1,1,1
    legend: 'False'
    marker1: '0'
    name: Data  into Rx File
    size: '50'
    srate: samp_rate
    stemplot: 'True'
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Time Signal
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    comment: Temporary output port
    stream_id: Payload Bits
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Pre-OFDM
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: Header Stream
  states: {}
- name: virtual_sink_0_2
  id: virtual_sink
  parameters:
    stream_id: tx_out
  states: {}
- name: virtual_sink_0_2_0
  id: virtual_sink
  parameters:
    stream_id: ddc_out
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: Baseband I
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: Payload IQ
  states: {}
- name: virtual_sink_1_1
  id: virtual_sink
  parameters:
    stream_id: Payload Stream
  states: {}
- name: virtual_sink_1_2
  id: virtual_sink
  parameters:
    stream_id: Baseband Q
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Header Bits
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    comment: Temporary input port
    stream_id: Payload Bits
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: Pre-OFDM
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: Time Signal
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: Payload IQ
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: Header Stream
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: tx_out
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: Payload Stream
  states: {}
- name: virtual_source_1_1
  id: virtual_source
  parameters:
    stream_id: ddc_out
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: Baseband I
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: Baseband Q
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0_0, '0']
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_0_0_0_0, '1']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0_0_1, '1']
- [audio_source_0, '0', blocks_multiply_xx_0_0_0, '1']
- [audio_source_0, '0', blocks_multiply_xx_0_0_0_0, '0']
- [audio_source_0, '0', qtgui_freq_sink_x_0_1, '0']
- [blocks_add_xx_0, '0', audio_sink_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_0_2, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_3, '0']
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_float_0, '0', virtual_sink_1, '0']
- [blocks_complex_to_float_0, '1', virtual_sink_1_2, '0']
- [blocks_delay_0, '0', blocks_multiply_xx_0, '1']
- [blocks_file_source_0, '0', blocks_char_to_float_0, '0']
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_float_to_complex_0, '0', fir_filter_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_tag_gate_0, '0']
- [blocks_multiply_xx_0, '0', digital_header_payload_demux_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0_0_0, '0', blocks_float_to_complex_0, '0']
- [blocks_multiply_xx_0_0_0_0, '0', blocks_float_to_complex_0, '1']
- [blocks_multiply_xx_0_0_1, '0', blocks_add_xx_0, '1']
- [blocks_repack_bits_bb_0, '0', virtual_sink_0_0, '0']
- [blocks_repack_bits_bb_0_0, '0', header_bits, '0']
- [blocks_repack_bits_bb_0_1, '0', digital_crc32_bb_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [blocks_tag_gate_0, '0', blocks_throttle2_0, '0']
- [blocks_tag_gate_0, '0', blocks_throttle_0, '0']
- [blocks_tag_gate_0_0, '0', blocks_char_to_float_1, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0_0_0, '0']
- [blocks_throttle2_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_constellation_decoder_cb_0, '0', digital_packet_headerparser_b_0, '0']
- [digital_constellation_decoder_cb_1, '0', blocks_repack_bits_bb_0_1, '0']
- [digital_crc32_bb_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_crc32_bb_0_0, '0', blocks_file_sink_0, '0']
- [digital_crc32_bb_0_0, '0', blocks_tag_debug_1, '0']
- [digital_crc32_bb_0_0, '0', blocks_tag_gate_0_0, '0']
- [digital_header_payload_demux_0, '0', virtual_sink_0_1, '0']
- [digital_header_payload_demux_0, '1', virtual_sink_1_1, '0']
- [digital_ofdm_carrier_allocator_cvc_0, '0', fft_vxx_0, '0']
- [digital_ofdm_chanest_vcvc_0, '0', digital_ofdm_frame_equalizer_vcvc_0, '0']
- [digital_ofdm_cyclic_prefixer_0, '0', virtual_sink_0, '0']
- [digital_ofdm_frame_equalizer_vcvc_0, '0', digital_ofdm_serializer_vcc_header, '0']
- [digital_ofdm_frame_equalizer_vcvc_1, '0', digital_ofdm_serializer_vcc_payload, '0']
- [digital_ofdm_serializer_vcc_header, '0', digital_constellation_decoder_cb_0, '0']
- [digital_ofdm_serializer_vcc_payload, '0', qtgui_const_sink_x_0, '0']
- [digital_ofdm_serializer_vcc_payload, '0', virtual_sink_1_0, '0']
- [digital_ofdm_sync_sc_cfb_0, '0', analog_frequency_modulator_fc_0, '0']
- [digital_ofdm_sync_sc_cfb_0, '1', digital_header_payload_demux_0, '1']
- [digital_packet_headerparser_b_0, header_data, digital_header_payload_demux_0, header_data]
- [digital_protocol_formatter_bb_0, '0', blocks_repack_bits_bb_0_0, '0']
- [fft_vxx_0, '0', digital_ofdm_cyclic_prefixer_0, '0']
- [fft_vxx_0_0, '0', digital_ofdm_chanest_vcvc_0, '0']
- [fft_vxx_1, '0', digital_ofdm_frame_equalizer_vcvc_1, '0']
- [fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_1_0, '0']
- [fir_filter_xxx_0, '0', virtual_sink_0_2_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_complex_to_float_0, '0']
- [virtual_source_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [virtual_source_0_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [virtual_source_0_0_0, '0', digital_ofdm_carrier_allocator_cvc_0, '0']
- [virtual_source_0_0_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_0_0_1, '0', digital_constellation_decoder_cb_1, '0']
- [virtual_source_0_1, '0', fft_vxx_0_0, '0']
- [virtual_source_1, '0', blocks_multiply_xx_0_0_0, '1']
- [virtual_source_1, '0', blocks_multiply_xx_0_0_0_0, '0']
- [virtual_source_1, '0', qtgui_freq_sink_x_0_1, '0']
- [virtual_source_1_0, '0', fft_vxx_1, '0']
- [virtual_source_1_1, '0', blocks_delay_0, '0']
- [virtual_source_1_1, '0', digital_ofdm_sync_sc_cfb_0, '0']
- [virtual_source_1_1, '0', qtgui_time_sink_x_1, '0']
- [virtual_source_2, '0', blocks_multiply_xx_0_0, '1']
- [virtual_source_2_0, '0', blocks_multiply_xx_0_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
